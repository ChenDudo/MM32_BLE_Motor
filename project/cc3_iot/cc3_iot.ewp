# IAR project cc3_iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F031C6T MindMotion MM32F031C6T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MZ309; __MM32_MB018; OVERTIME=0; CLOCK=8000000; _USER_RESOURCE; _SYS_RESOURCE_IT; __SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\driver\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc; ..\..\app\cc3_iot\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cc3_iot.srec
  ILINK.IlinkOutputFile: cc3_iot.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../app/cc3_iot/: adc.c hts.c iot.c lps.c lsm.c main.c sensor_common.c uart.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_i2c.c bsp_key.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_spi.c bsp_tim.c bsp_uart.c
  group driver
    ../../driver/: common.c drv.c drv_adc.c drv_aes.c drv_bkp.c drv_comp.c drv_crc.c drv_crs.c drv_dac.c drv_display.c drv_div.c drv_dma.c drv_eeprom.c drv_exti.c drv_gpio.c drv_i2c.c drv_iwdg.c drv_keyboard.c drv_mco.c drv_opamp.c drv_power.c drv_protect.c drv_rtc.c drv_spi.c drv_sqrt.c drv_tim.c drv_uart.c drv_wwdg.c
  group lib
    ../../lib/HAL_lib/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../lib/startup/: resource.c startup_mm32.c system_mm32.c
